Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 53c1ac85-e586-454a-ab3d-e872ed512a1b, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-04T12:57:49+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11927680_EU_PDR510TOPEL_IG:52510004_EU_11927680_PDR510TOPEL_IG, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Iron_Grey, <Unnamed>, z_Miele_Design_Stainless_Steel, z_Miele_Design_Glass, z_Miele_Connection_Electric, Default, z_Miele_Connection_ExhaustAir
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 700 mm; Height: 1020 mm; Depth: 763 mm
Pset_BuildingElementProxyCommon - Reference: 52510004_EU_11927680_PDR510TOPEL_IG; sets with these values: 2
